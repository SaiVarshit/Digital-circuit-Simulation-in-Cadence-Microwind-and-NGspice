CIRCUIT C:\Users\vvsai\Downloads\CMOS\Export Microwind\Export Microwind\Example.MSK
*
* IC Technology: CMOS 0.12µm - 6 Metal
*
VDD 1 0 DC 1.20
VA7 26 0 PULSE(0.00 3.30 15.97N 0.03N 0.03N 15.97N 32.00N)
VA3 27 0 PULSE(0.00 3.30 0.98N 0.03N 0.03N 0.97N 2.00N)
VA5 28 0 PULSE(0.00 3.30 3.98N 0.03N 0.03N 3.98N 8.00N)
VA1 29 0 PULSE(0.00 3.30 0.23N 0.03N 0.03N 0.23N 0.50N)
VA6 30 0 PULSE(0.00 3.30 7.98N 0.03N 0.03N 7.97N 16.00N)
VA2 31 0 PULSE(0.00 3.30 0.48N 0.03N 0.03N 0.48N 1.00N)
VA4 32 0 PULSE(0.00 3.30 1.97N 0.03N 0.03N 1.97N 4.00N)
VA0 33 0 PULSE(0.00 3.30 0.23N 0.03N 0.03N 0.23N 0.50N)
VSEL0 45 0 PULSE(0.00 5.00 1.97N 0.03N 0.03N 1.97N 4.00N)
VSEL2 46 0 PULSE(0.00 5.00 7.98N 0.03N 0.03N 7.97N 16.00N)
VSEL1 47 0 PULSE(0.00 5.00 3.98N 0.03N 0.03N 3.98N 8.00N)
*
* List of nodes
* "Output" corresponds to n°11
* "A7" corresponds to n°26
* "A3" corresponds to n°27
* "A5" corresponds to n°28
* "A1" corresponds to n°29
* "A6" corresponds to n°30
* "A2" corresponds to n°31
* "A4" corresponds to n°32
* "A0" corresponds to n°33
* "SEL0" corresponds to n°45
* "SEL2" corresponds to n°46
* "SEL1" corresponds to n°47
*
* MOS devices
MN1 11 38 10 0 N1  W= 0.24U L= 0.12U
MN2 12 13 11 0 N1  W= 0.24U L= 0.12U
MN3 0 38 13 0 N1  W= 0.24U L= 0.12U
MN4 12 40 16 0 N1  W= 0.24U L= 0.12U
MN5 10 42 17 0 N1  W= 0.24U L= 0.12U
MN6 18 20 12 0 N1  W= 0.24U L= 0.12U
MN7 19 21 10 0 N1  W= 0.24U L= 0.12U
MN8 0 40 20 0 N1  W= 0.24U L= 0.12U
MN9 0 42 21 0 N1  W= 0.24U L= 0.12U
MN10 17 43 26 0 N1  W= 0.24U L= 0.12U
MN11 16 44 27 0 N1  W= 0.24U L= 0.12U
MN12 19 41 28 0 N1  W= 0.24U L= 0.12U
MN13 18 39 29 0 N1  W= 0.24U L= 0.12U
MN14 30 34 17 0 N1  W= 0.24U L= 0.12U
MN15 31 35 16 0 N1  W= 0.24U L= 0.12U
MN16 32 36 19 0 N1  W= 0.24U L= 0.12U
MN17 33 37 18 0 N1  W= 0.24U L= 0.12U
MN18 0 43 34 0 N1  W= 0.24U L= 0.12U
MN19 0 44 35 0 N1  W= 0.24U L= 0.12U
MN20 0 41 36 0 N1  W= 0.24U L= 0.12U
MN21 0 39 37 0 N1  W= 0.24U L= 0.12U
MP1 11 13 10 1 P1  W= 0.72U L= 0.12U
MP2 12 38 11 1 P1  W= 0.72U L= 0.12U
MP3 1 38 13 1 P1  W= 0.72U L= 0.12U
MP4 12 20 16 1 P1  W= 0.72U L= 0.12U
MP5 10 21 17 1 P1  W= 0.72U L= 0.12U
MP6 18 40 12 1 P1  W= 0.72U L= 0.12U
MP7 19 42 10 1 P1  W= 0.72U L= 0.12U
MP8 1 40 20 1 P1  W= 0.72U L= 0.12U
MP9 1 42 21 1 P1  W= 0.72U L= 0.12U
MP10 17 34 26 1 P1  W= 0.72U L= 0.12U
MP11 16 35 27 1 P1  W= 0.72U L= 0.12U
MP12 19 36 28 1 P1  W= 0.72U L= 0.12U
MP13 18 37 29 1 P1  W= 0.72U L= 0.12U
MP14 30 43 17 1 P1  W= 0.72U L= 0.12U
MP15 31 44 16 1 P1  W= 0.72U L= 0.12U
MP16 32 41 19 1 P1  W= 0.72U L= 0.12U
MP17 33 39 18 1 P1  W= 0.72U L= 0.12U
MP18 1 43 34 1 P1  W= 0.72U L= 0.12U
MP19 1 44 35 1 P1  W= 0.72U L= 0.12U
MP20 1 41 36 1 P1  W= 0.72U L= 0.12U
MP21 1 39 37 1 P1  W= 0.72U L= 0.12U
*
C2 1 0  2.326fF
C3 1 0  2.326fF
C4 1 0  2.326fF
C5 1 0  2.326fF
C6 1 0  2.326fF
C7 1 0  2.326fF
C8 1 0  2.326fF
C10 10 0  1.785fF
C11 11 0  0.621fF
C12 12 0  1.827fF
C13 13 0  0.518fF
C16 16 0  1.850fF
C17 17 0  1.906fF
C18 18 0  1.918fF
C19 19 0  1.746fF
C20 20 0  0.518fF
C21 21 0  0.518fF
C26 26 0  0.788fF
C27 27 0  0.786fF
C28 28 0  0.786fF
C29 29 0  0.784fF
C30 30 0  0.721fF
C31 31 0  0.719fF
C32 32 0  0.719fF
C33 33 0  0.717fF
C34 34 0  0.518fF
C35 35 0  0.518fF
C36 36 0  0.518fF
C37 37 0  0.518fF
C38 38 0  0.606fF
C39 39 0  0.606fF
C40 40 0  0.606fF
C41 41 0  0.606fF
C42 42 0  0.606fF
C43 43 0  0.606fF
C44 44 0  0.606fF
C45 45 0  1.811fF
C46 46 0  0.093fF
C47 47 0  0.698fF
*
*
* n-MOS Model 1 :
* low leakage
.MODEL N1 NMOS LEVEL=1 VTO=0.45 UO=600.000 TOX= 2.0E-9
+GAMMA=0.400 PHI=0.200
+CGSO=100.0p CGDO=100.0p
+CGBO= 60.0p CJSW=240.0p
*
* p-MOS Model 1:
* low leakage
.MODEL P1 PMOS LEVEL=1 VTO=-0.45 UO=200.000 TOX= 2.0E-9
+GAMMA=0.400 PHI=0.200
+CGSO=100.0p CGDO=100.0p
+CGBO= 60.0p CJSW=240.0p
*
* Transient analysis
*
.TEMP 27.0
.TRAN 0.1N 10.00N
* (Pspice)
.PROBE
.END
