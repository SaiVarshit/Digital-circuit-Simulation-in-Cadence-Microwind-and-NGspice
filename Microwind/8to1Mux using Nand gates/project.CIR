CIRCUIT C:\Users\vvsai\Downloads\CMOS\Export Microwind\Export Microwind\project.MSK
*
* IC Technology: CMOS 0.12µm - 6 Metal
*
VDD 1 0 DC 1.20
VS1 141 0 PULSE(0.00 1.20 0.48N 0.03N 0.03N 0.48N 1.00N)
VS2 143 0 PULSE(0.00 1.20 0.98N 0.03N 0.03N 0.97N 2.00N)
VA0 144 0 PULSE(0.00 1.20 0.23N 0.03N 0.03N 0.23N 0.50N)
VS0 145 0 PULSE(0.00 1.20 0.23N 0.03N 0.03N 0.23N 0.50N)
VA2 146 0 PULSE(0.00 1.20 0.98N 0.03N 0.03N 0.97N 2.00N)
VA3 147 0 PULSE(0.00 1.20 1.97N 0.03N 0.03N 1.97N 4.00N)
VA1 148 0 PULSE(0.00 1.20 0.48N 0.03N 0.03N 0.48N 1.00N)
VA6 149 0 PULSE(0.00 1.20 0.98N 0.03N 0.03N 0.97N 2.00N)
VA5 150 0 PULSE(0.00 1.20 0.48N 0.03N 0.03N 0.48N 1.00N)
VA7 151 0 PULSE(0.00 1.20 1.97N 0.03N 0.03N 1.97N 4.00N)
VA4 152 0 PULSE(0.00 1.20 0.23N 0.03N 0.03N 0.23N 0.50N)
*
* List of nodes
* "Yout" corresponds to n°57
* "N100" corresponds to n°100
* "N103" corresponds to n°103
* "N104" corresponds to n°104
* "N106" corresponds to n°106
* "N107" corresponds to n°107
* "N109" corresponds to n°109
* "N113" corresponds to n°113
* "N114" corresponds to n°114
* "N115" corresponds to n°115
* "N117" corresponds to n°117
* "N118" corresponds to n°118
* "N120" corresponds to n°120
* "N123" corresponds to n°123
* "N124" corresponds to n°124
* "N126" corresponds to n°126
* "N127" corresponds to n°127
* "N129" corresponds to n°129
* "N131" corresponds to n°131
* "N133" corresponds to n°133
* "N134" corresponds to n°134
* "N137" corresponds to n°137
* "N138" corresponds to n°138
* "N139" corresponds to n°139
* "N140" corresponds to n°140
* "S1" corresponds to n°141
* "N142" corresponds to n°142
* "S2" corresponds to n°143
* "A0" corresponds to n°144
* "S0" corresponds to n°145
* "A2" corresponds to n°146
* "A3" corresponds to n°147
* "A1" corresponds to n°148
* "A6" corresponds to n°149
* "A5" corresponds to n°150
* "A7" corresponds to n°151
* "A4" corresponds to n°152
* "N153" corresponds to n°153
* "N154" corresponds to n°154
* "N155" corresponds to n°155
*
* MOS devices
MN1 81 153 0 0 N1  W= 0.60U L= 0.12U
MN2 29 153 81 0 N1  W= 0.60U L= 0.12U
MN3 83 154 0 0 N1  W= 0.60U L= 0.12U
MN4 31 155 83 0 N1  W= 0.60U L= 0.12U
MN5 85 145 0 0 N1  W= 0.60U L= 0.12U
MN6 86 141 85 0 N1  W= 0.60U L= 0.12U
MN7 32 151 86 0 N1  W= 0.60U L= 0.12U
MN8 88 32 0 0 N1  W= 0.60U L= 0.12U
MN9 35 36 88 0 N1  W= 0.60U L= 0.12U
MN10 90 145 0 0 N1  W= 0.60U L= 0.12U
MN11 92 53 90 0 N1  W= 0.60U L= 0.12U
MN12 93 35 0 0 N1  W= 0.60U L= 0.12U
MN13 36 150 92 0 N1  W= 0.60U L= 0.12U
MN14 39 35 93 0 N1  W= 0.60U L= 0.12U
MN15 95 141 0 0 N1  W= 0.60U L= 0.12U
MN16 97 59 95 0 N1  W= 0.60U L= 0.12U
MN17 99 39 0 0 N1  W= 0.60U L= 0.12U
MN18 40 149 97 0 N1  W= 0.60U L= 0.12U
MN19 100 40 0 0 N1  W= 0.60U L= 0.12U
MN20 44 49 99 0 N1  W= 0.60U L= 0.12U
MN21 45 46 100 0 N1  W= 0.60U L= 0.12U
MN22 103 53 0 0 N1  W= 0.60U L= 0.12U
MN23 104 45 0 0 N1  W= 0.60U L= 0.12U
MN24 106 59 103 0 N1  W= 0.60U L= 0.12U
MN25 49 45 104 0 N1  W= 0.60U L= 0.12U
MN26 107 44 0 0 N1  W= 0.60U L= 0.12U
MN27 46 152 106 0 N1  W= 0.60U L= 0.12U
MN28 51 143 107 0 N1  W= 0.60U L= 0.12U
MN29 109 141 0 0 N1  W= 0.60U L= 0.12U
MN30 53 141 109 0 N1  W= 0.60U L= 0.12U
MN31 113 51 0 0 N1  W= 0.60U L= 0.12U
MN32 114 143 0 0 N1  W= 0.60U L= 0.12U
MN33 115 145 0 0 N1  W= 0.60U L= 0.12U
MN34 57 66 113 0 N1  W= 0.60U L= 0.12U
MN35 58 143 114 0 N1  W= 0.60U L= 0.12U
MN36 59 145 115 0 N1  W= 0.60U L= 0.12U
MN37 117 141 0 0 N1  W= 0.60U L= 0.12U
MN38 118 59 117 0 N1  W= 0.60U L= 0.12U
MN39 60 146 118 0 N1  W= 0.60U L= 0.12U
MN40 120 60 0 0 N1  W= 0.60U L= 0.12U
MN41 63 65 120 0 N1  W= 0.60U L= 0.12U
MN42 123 58 0 0 N1  W= 0.60U L= 0.12U
MN43 124 141 0 0 N1  W= 0.60U L= 0.12U
MN44 66 74 123 0 N1  W= 0.60U L= 0.12U
MN45 126 145 124 0 N1  W= 0.60U L= 0.12U
MN46 127 63 0 0 N1  W= 0.60U L= 0.12U
MN47 65 147 126 0 N1  W= 0.60U L= 0.12U
MN48 69 63 127 0 N1  W= 0.60U L= 0.12U
MN49 129 53 0 0 N1  W= 0.60U L= 0.12U
MN50 131 145 129 0 N1  W= 0.60U L= 0.12U
MN51 133 69 0 0 N1  W= 0.60U L= 0.12U
MN52 70 148 131 0 N1  W= 0.60U L= 0.12U
MN53 134 70 0 0 N1  W= 0.60U L= 0.12U
MN54 74 79 133 0 N1  W= 0.60U L= 0.12U
MN55 75 76 134 0 N1  W= 0.60U L= 0.12U
MN56 137 59 0 0 N1  W= 0.60U L= 0.12U
MN57 138 75 0 0 N1  W= 0.60U L= 0.12U
MN58 139 53 137 0 N1  W= 0.60U L= 0.12U
MN59 79 75 138 0 N1  W= 0.60U L= 0.12U
MN60 76 144 139 0 N1  W= 0.60U L= 0.12U
MP1 29 153 1 1 P1  W= 1.20U L= 0.12U
MP2 31 154 1 1 P1  W= 0.60U L= 0.12U
MP3 1 155 31 1 P1  W= 0.60U L= 0.12U
MP4 1 145 32 1 P1  W= 0.60U L= 0.12U
MP5 32 141 1 1 P1  W= 0.60U L= 0.12U
MP6 1 151 32 1 P1  W= 0.60U L= 0.12U
MP7 35 32 1 1 P1  W= 0.60U L= 0.12U
MP8 1 36 35 1 P1  W= 0.60U L= 0.12U
MP9 1 145 36 1 P1  W= 0.60U L= 0.12U
MP10 36 53 1 1 P1  W= 0.60U L= 0.12U
MP11 39 35 1 1 P1  W= 1.20U L= 0.12U
MP12 1 150 36 1 P1  W= 0.60U L= 0.12U
MP13 1 141 40 1 P1  W= 0.60U L= 0.12U
MP14 40 59 1 1 P1  W= 0.60U L= 0.12U
MP15 44 39 1 1 P1  W= 0.60U L= 0.12U
MP16 1 149 40 1 P1  W= 0.60U L= 0.12U
MP17 45 40 1 1 P1  W= 0.60U L= 0.12U
MP18 1 49 44 1 P1  W= 0.60U L= 0.12U
MP19 1 46 45 1 P1  W= 0.60U L= 0.12U
MP20 1 53 46 1 P1  W= 0.60U L= 0.12U
MP21 49 45 1 1 P1  W= 1.20U L= 0.12U
MP22 46 59 1 1 P1  W= 0.60U L= 0.12U
MP23 51 44 1 1 P1  W= 0.60U L= 0.12U
MP24 1 152 46 1 P1  W= 0.60U L= 0.12U
MP25 1 143 51 1 P1  W= 0.60U L= 0.12U
MP26 53 141 1 1 P1  W= 1.20U L= 0.12U
MP27 57 51 1 1 P1  W= 0.60U L= 0.12U
MP28 58 143 1 1 P1  W= 1.20U L= 0.12U
MP29 59 145 1 1 P1  W= 1.20U L= 0.12U
MP30 1 66 57 1 P1  W= 0.60U L= 0.12U
MP31 1 141 60 1 P1  W= 0.60U L= 0.12U
MP32 60 59 1 1 P1  W= 0.60U L= 0.12U
MP33 1 146 60 1 P1  W= 0.60U L= 0.12U
MP34 63 60 1 1 P1  W= 0.60U L= 0.12U
MP35 1 65 63 1 P1  W= 0.60U L= 0.12U
MP36 66 58 1 1 P1  W= 0.60U L= 0.12U
MP37 1 141 65 1 P1  W= 0.60U L= 0.12U
MP38 1 74 66 1 P1  W= 0.60U L= 0.12U
MP39 65 145 1 1 P1  W= 0.60U L= 0.12U
MP40 69 63 1 1 P1  W= 1.20U L= 0.12U
MP41 1 147 65 1 P1  W= 0.60U L= 0.12U
MP42 1 53 70 1 P1  W= 0.60U L= 0.12U
MP43 70 145 1 1 P1  W= 0.60U L= 0.12U
MP44 74 69 1 1 P1  W= 0.60U L= 0.12U
MP45 1 148 70 1 P1  W= 0.60U L= 0.12U
MP46 75 70 1 1 P1  W= 0.60U L= 0.12U
MP47 1 79 74 1 P1  W= 0.60U L= 0.12U
MP48 1 76 75 1 P1  W= 0.60U L= 0.12U
MP49 1 59 76 1 P1  W= 0.60U L= 0.12U
MP50 79 75 1 1 P1  W= 1.20U L= 0.12U
MP51 76 53 1 1 P1  W= 0.60U L= 0.12U
MP52 1 144 76 1 P1  W= 0.60U L= 0.12U
*
C2 1 0  0.792fF
C3 1 0  0.792fF
C4 1 0  0.792fF
C5 1 0  0.792fF
C6 1 0  0.634fF
C7 1 0  0.634fF
C8 1 0  0.634fF
C9 1 0  0.634fF
C10 1 0  0.634fF
C11 1 0  0.634fF
C12 1 0  0.634fF
C13 1 0  0.634fF
C14 1 0  0.634fF
C15 1 0  0.634fF
C16 1 0  0.634fF
C17 1 0  0.634fF
C18 1 0  0.634fF
C19 1 0  0.634fF
C20 1 0  0.634fF
C21 1 0  0.634fF
C22 1 0  0.634fF
C23 1 0  0.792fF
C24 1 0  0.792fF
C25 1 0  0.792fF
C26 1 0  0.792fF
C27 1 0  0.634fF
C28 1 0  0.472fF
C29 29 0  0.446fF
C30 1 0  0.472fF
C31 31 0  0.446fF
C32 32 0  1.077fF
C33 1 0  0.472fF
C34 1 0  0.472fF
C35 35 0  0.749fF
C36 36 0  1.139fF
C37 1 0  0.472fF
C38 1 0  0.472fF
C39 39 0  0.774fF
C40 40 0  1.069fF
C41 1 0  0.472fF
C42 1 0  0.472fF
C43 1 0  0.472fF
C44 44 0  0.818fF
C45 45 0  0.766fF
C46 46 0  1.245fF
C47 1 0  0.472fF
C48 1 0  0.472fF
C49 49 0  0.923fF
C50 1 0  0.472fF
C51 51 0  1.013fF
C52 1 0  0.432fF
C53 53 0  3.084fF
C54 1 0  0.472fF
C55 1 0  0.472fF
C56 1 0  0.432fF
C57 57 0  0.446fF
C58 58 0  0.767fF
C59 59 0  3.415fF
C60 60 0  1.077fF
C61 1 0  0.472fF
C62 1 0  0.472fF
C63 63 0  0.749fF
C64 1 0  0.472fF
C65 65 0  1.048fF
C66 66 0  1.232fF
C67 1 0  0.472fF
C68 1 0  0.472fF
C69 69 0  0.774fF
C70 70 0  1.069fF
C71 1 0  0.472fF
C72 1 0  0.472fF
C73 1 0  0.472fF
C74 74 0  1.155fF
C75 75 0  0.766fF
C76 76 0  1.245fF
C77 1 0  0.472fF
C78 1 0  0.472fF
C79 79 0  0.923fF
C81 81 0  0.212fF
C83 83 0  0.212fF
C85 85 0  0.212fF
C86 86 0  0.212fF
C88 88 0  0.212fF
C90 90 0  0.212fF
C92 92 0  0.212fF
C93 93 0  0.212fF
C95 95 0  0.212fF
C97 97 0  0.212fF
C99 99 0  0.212fF
C100 100 0  0.212fF
C103 103 0  0.212fF
C104 104 0  0.212fF
C106 106 0  0.212fF
C107 107 0  0.212fF
C109 109 0  0.212fF
C113 113 0  0.212fF
C114 114 0  0.212fF
C115 115 0  0.212fF
C117 117 0  0.212fF
C118 118 0  0.212fF
C120 120 0  0.212fF
C123 123 0  0.212fF
C124 124 0  0.212fF
C126 126 0  0.212fF
C127 127 0  0.212fF
C129 129 0  0.212fF
C131 131 0  0.212fF
C133 133 0  0.212fF
C134 134 0  0.212fF
C137 137 0  0.212fF
C138 138 0  0.212fF
C139 139 0  0.212fF
C141 141 0  2.789fF
C143 143 0  0.582fF
C144 144 0  0.130fF
C145 145 0  3.717fF
C146 146 0  0.130fF
C147 147 0  0.130fF
C148 148 0  0.130fF
C149 149 0  0.130fF
C150 150 0  0.130fF
C151 151 0  0.130fF
C152 152 0  0.130fF
C153 153 0  0.259fF
C154 154 0  0.121fF
C155 155 0  0.121fF
*
* n-MOS Model 3 :
* low leakage
.MODEL N1 NMOS LEVEL=3 VTO=0.40 UO=600.000 TOX= 2.0E-9
+LD =0.000U THETA=0.500 GAMMA=0.400
+PHI=0.200 KAPPA=0.060 VMAX=120.00K
+CGSO=100.0p CGDO=100.0p
+CGBO= 60.0p CJSW=240.0p
*
* p-MOS Model 3:
* low leakage
.MODEL P1 PMOS LEVEL=3 VTO=-0.45 UO=200.000 TOX= 2.0E-9
+LD =0.000U THETA=0.300 GAMMA=0.400
+PHI=0.200 KAPPA=0.060 VMAX=110.00K
+CGSO=100.0p CGDO=100.0p
+CGBO= 60.0p CJSW=240.0p
*
* Transient analysis
*
.TEMP 27.0
.TRAN 0.1N 5.00N
* (Winspice)
*#run
*#plot
.END
